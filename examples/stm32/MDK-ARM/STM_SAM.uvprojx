# Keil uVision project STM_SAM.uvprojx, settings and files
target STM_SAM (6160000::V6.16::ARMCLANG)
  device: STM32L4R5ZITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IRAM(0x20000000-0x2002FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM_SAM +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L4R5xx,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../SAM_ATCDRV;../../../SAM_ATCDRV/SamCode;../Drivers/CMSIS/Include;../BSP/;../BSP/inc;../Lib/lwrb-develop/lwrb/src/include/lwrb
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group Application/MDK-ARM
    ./: startup_stm32l4r5xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c stm32l4xx_ll_usart.c stm32l4xx_ll_rcc.c stm32l4xx_ll_dma.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group SAM_Core
    ../../../SAM_ATCDRV/SamCode/: SamAtc.c SamAudio.c SamDebug.c SamFota.c SamMdm.c SamMqtt.c SamSms.c SamSocket.c SamSub.c SamTTS.c
  group SAM_Service
    ../../../SAM_ATCDRV/: SamAudioSrv.c SamFotaSrv.c SamMdmSrv.c SamMqttSrv.c SamSmsSrv.c SamSocketSrv.c SamTester.c SamTTSSrv.c
  group BSP
    ../BSP/: bsp.c
    ../BSP/src/: bsp_uart.c
  group lwrb
    ../Lib/lwrb-develop/lwrb/src/lwrb/: lwrb.c
software components: CMSIS:CORE 6.1.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
